# Keil uVision project fakeload.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: fakeload +hex
  c flags: Optimize=8
  c include: .\Display;.\FakeLoad;.\Key;.\System;.\Utility
  group User
    ./: main.c
  group System
    ./System/: Delay.c Delay.h stc89c52.h Timer.c Timer.h TLCx543.c TLCx543.h
  group Key
    ./Key/: key.c key.h peripheral.c peripheral.h encode.c
  group Display
    ./Display/: Display.c Display.h LCD1602.c LCD1602.h
  group FakeLoad
    ./FakeLoad/: fakeload.c fakeload.h pcf8574.c pcf8574.h
