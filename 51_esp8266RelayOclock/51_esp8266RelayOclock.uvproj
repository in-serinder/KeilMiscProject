# Keil uVision project 51_esp8266RelayOclock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 51_esp8266RelayOclock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Ser.c Ser.h Timer.c Timer.h Util.c Util.h Max7219.c Max7219.h TM1637.c TM1637.h
