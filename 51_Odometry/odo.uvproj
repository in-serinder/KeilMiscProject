# Keil uVision project odo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: odo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware;.\System
  group User
    ./: main.c Display.c
  group System
    ./System/: Delay.c Delay.h stc89c52.h uart.c uart.h
  group Hardware
    ./Hardware/: 24c64.c MAX7219.c key.c led.c obo.c
