# Keil uVision project capsa.uvproj, settings and files
target Capsa (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x43FF) CLOCK(22118400)
  output: capsa +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\;.\system;.\hardware;.\user
  group User
    ./user/: main.c app.c proto.c meta.c ui.c
  group System
    ./system/: board.c uart.c delay.c
  group Hardware
    ./hardware/: i2c_hw.c i2c_sw.c ee.c pcf8574.c ssd13xx.c
