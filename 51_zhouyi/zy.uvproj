# Keil uVision project zy.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: zy +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\System
  group Main
    ./: main.c
  group System
    ./System/: ADC.c ADC.h Delay.c Delay.h stc15w.h
