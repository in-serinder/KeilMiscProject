# Keil uVision project led.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: led +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Max7219.h Max7219.c Utils.c TM1637.c TM1637.h Timer.c Timer.h
