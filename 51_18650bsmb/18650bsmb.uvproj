# Keil uVision project 18650bsmb.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 18650bsmb
  c flags: Optimize=8 SizeSpeed=1
  c include: .\DRIVER;..\51_18650bsmb;.\SYS
  group USER
    ./: main.c stc15w.h
  group DRIVER
    ./DRIVER/: BAT.c BAT.h CHR.c CHR.h key.c key.h ssd13xx.c ssd13xx.h
  group SYS
    ./SYS/: Delay.c Delay.h
