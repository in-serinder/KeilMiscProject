# Keil uVision project copier.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(22118400)
  output: copier +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\;.\system;.\hardware;.\user
  group User
    ./user/: main.c copier.c proto.c display.c
  group System
    ./system/: uart.c delay.c
  group Hardware
    ./hardware/: board.c HW_24c64.c TM1637.c
