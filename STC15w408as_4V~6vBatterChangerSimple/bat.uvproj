# Keil uVision project bat.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: bat +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\System;..\STC15w408as_4V~6vBatterChangerSimple
  group Root
    ./: main.c
  group System
    ./System/: ADC.c ADC.h Delay.c Delay.h stc15w.h ChargerCTL.c ChargerCTL.h
