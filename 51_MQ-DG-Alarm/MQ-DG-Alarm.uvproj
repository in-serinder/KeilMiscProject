# Keil uVision project MQ-DG-Alarm.uvproj, settings and files
target MQ-DG-Alarm (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(22118400)
  output: MQ-DG-Alarm +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\;.\system;.\hardware;.\user
  group User
    ./user/: main.c
  group System
    ./system/: delay.c eeprom.c uart.c
  group Hardware
    ./hardware/: board.c TM1637.c adc.c key.c
