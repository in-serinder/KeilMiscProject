# Keil uVision project nfg.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: nfg +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Display;.\hardware;.\system
  group User
    ./: main.c
  group Display
    ./Display/: d12864.c
  group hardware
    ./hardware/: 24c64.c AS6C622_Serial.c SN74HC165N.c SN74HC595N.c
    ../../../Misc.Keil/51_function/: tm1638.c
  group system
    ./system/: delay.c uart.c
